options:
  parameters:
    generate_options: no_gui
    id: Radar
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/zg88/CEI/Sensing/Code/Radar/gnuradio/RX_1.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/zg88/CEI/Sensing/Code/Radar/gnuradio/RX_2.bin
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/zg88/CEI/Sensing/Code/Radar/gnuradio/TX_1.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/zg88/CEI/Sensing/Code/Radar/gnuradio/TX_2.bin
    repeat: 'True'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: 3e9
    center_freq1: 3e9
    clock_source0: external
    dev_args: '"serial=322A004"'
    gain0: '20'
    gain1: '20'
    nchan: '2'
    samp_rate: 25e6
    sd_spec0: A:0 B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: 3e9
    center_freq1: 3e9
    clock_source0: external
    dev_args: '"serial=322A004"'
    gain0: '10'
    gain1: '10'
    nchan: '2'
    samp_rate: 25e6
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_file_source_0_0, '0', uhd_usrp_sink_0, '1']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '1', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
