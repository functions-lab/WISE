options:
  parameters:
    generate_options: no_gui
    id: mult
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/zg88/CEI/Analog/Code/Library/tx2rx_mult/Buffer/Tx_1_1.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/zg88/CEI/Analog/Code/Library/tx2rx_mult/Buffer/Tx_1_2.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/zg88/CEI/Analog/Code/Library/tx2rx_mult/Buffer/Tx_1_3.bin
    repeat: 'True'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    ant2: '"TX/RX"'
    center_freq0: 3e9
    center_freq1: 3e9
    center_freq2: 3e9
    clock_source0: external
    dev_args: '"addr0=192.168.70.3,addr1=192.168.70.5,addr1=192.168.70.6"'
    gain0: '20'
    gain1: '20'
    gain2: '20'
    nchan: '3'
    samp_rate: 100e6
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_file_source_0_0, '0', uhd_usrp_sink_0, '1']
- [blocks_file_source_0_0_0, '0', uhd_usrp_sink_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
