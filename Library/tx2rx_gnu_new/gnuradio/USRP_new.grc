options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/zg88/CEI/Analog/Code/Library/tx2rx_gnu/gnuradio/RX_1.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/zg88/CEI/Analog/Code/Library/tx2rx_gnu/gnuradio/RX_4.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/zg88/CEI/Analog/Code/Library/tx2rx_gnu/gnuradio/RX_3.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: /home/zg88/CEI/Analog/Code/Library/tx2rx_gnu/gnuradio/RX_2.bin
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/zg88/CEI/Analog/Code/Library/tx2rx_gnu/gnuradio/TX_1.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/zg88/CEI/Analog/Code/Library/tx2rx_gnu/gnuradio/TX_2.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: /home/zg88/CEI/Analog/Code/Library/tx2rx_gnu/gnuradio/TX_4.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    file: /home/zg88/CEI/Analog/Code/Library/tx2rx_gnu/gnuradio/TX_3.bin
    repeat: 'True'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    ant2: '"TX/RX"'
    ant3: '"TX/RX"'
    center_freq0: 2e9
    center_freq1: 2e9
    center_freq2: 2e9
    center_freq3: 2e9
    dev_addr: '"addr0=192.168.10.2,master_clock_rate=500e6"'
    gain0: '10'
    gain1: '10'
    gain2: '10'
    gain3: '10'
    nchan: '4'
    samp_rate: 1e6
    sd_spec0: A:0 B:0 A:1 B:1
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    ant2: '"RX2"'
    ant3: '"RX2"'
    center_freq0: 2e9
    center_freq1: 2e9
    center_freq2: 2e9
    center_freq3: 2e9
    dev_addr: '"addr0=192.168.10.2,master_clock_rate=500e6"'
    gain0: '10'
    gain1: '10'
    gain2: '10'
    gain3: '10'
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: 1e6
    sd_spec0: A:0 B:0 A:1 B:1
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_file_source_0_0, '0', uhd_usrp_sink_0, '1']
- [blocks_file_source_0_1, '0', uhd_usrp_sink_0, '3']
- [blocks_file_source_0_2, '0', uhd_usrp_sink_0, '2']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '1', blocks_file_sink_0_2, '0']
- [uhd_usrp_source_0, '2', blocks_file_sink_0_1, '0']
- [uhd_usrp_source_0, '3', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
